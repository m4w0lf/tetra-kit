options:
  parameters:
    generate_options: qt_gui
    id: pi4dqpsk_rx_equalizer
    output_language: python
  states: {}

blocks:
- name: adaptative_alg
  id: variable_adaptive_algorithm
  parameters:
    cons: constel_0
    modulus: '1'
    step_size: '0.01'
    type: cma
  states: {}
- name: arity
  id: variable
  parameters:
    value: '4'
  states: {}
- name: channel_rate
  id: variable
  parameters:
    value: '36000'
  states: {}
- name: constel
  id: variable_constellation
  parameters:
    const_points: '[1-1j, 1+1j, -1-1j, 1-1j]'
    precision: '8'
    soft_dec_lut: '''auto'''
    type: dqpsk
  states: {state: disabled}
- name: constel_0
  id: variable_constellation
  parameters:
    const_points: '[1-1j, 1+1j, -1-1j, 1-1j]'
    precision: '8'
    soft_dec_lut: '''auto'''
    type: dqpsk
  states: {}
- name: decim
  id: variable
  parameters:
    value: '32'
  states: {}
- name: freq_offset_khz
  id: variable_qtgui_entry
  parameters:
    gui_hint: '[1,1]'
    label: Baseband offset [kHz]
    type: real
    value: '50'
  states: {}
- name: frequency_mhz
  id: variable_qtgui_entry
  parameters:
    gui_hint: '[1,0]'
    label: Frequency [MHz]
    type: real
    value: '467.5625'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: ppm_corr
  id: variable_qtgui_range
  parameters:
    gui_hint: '[2,0,1,2]'
    label: PPM correction
    rangeType: int
    start: '-20'
    step: '1'
    stop: '15'
    value: '0'
    widget: counter
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 11*sps*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '2'
  states: {}
- name: analog_feedforward_agc_cc_0
  id: analog_feedforward_agc_cc
  parameters:
    num_samples: '8'
    reference: '1'
  states: {}
- name: blocks_udp_sink_1_0
  id: blocks_udp_sink
  parameters:
    eof: 'False'
    ipaddr: 127.0.0.1
    port: '42000'
    psize: '1472'
    type: byte
    vlen: '1'
  states: {}
- name: blocks_unpack_k_bits_bb_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: constel_0.bits_per_symbol()
  states: {}
- name: digital_constellation_decoder_cb_0_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: constel_0
  states: {}
- name: digital_diff_phasor_cc_0_0
  id: digital_diff_phasor_cc
  parameters: {}
  states: {}
- name: digital_fll_band_edge_cc_0
  id: digital_fll_band_edge_cc
  parameters:
    filter_size: '45'
    rolloff: '0.35'
    samps_per_sym: sps
    type: cc
    w: cmath.pi/100.0
  states: {}
- name: digital_linear_equalizer_0
  id: digital_linear_equalizer
  parameters:
    alg: adaptative_alg
    num_taps: '15'
    sps: sps
  states: {}
- name: digital_map_bb_0_0
  id: digital_map_bb
  parameters:
    map: constel_0.pre_diff_code()
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: 2*cmath.pi/100.0
    max_dev: '1.5'
    osps: sps
    sps: sps
    taps: rrc_taps
    type: ccf
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: freq_offset_khz*1e3
    decim: decim
    samp_rate: samp_rate
    taps: firdes.low_pass(1,samp_rate,12500,12500*0.2)
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import cmath
  states: {}
- name: mmse_resampler_xx_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: float(samp_rate)/(float(decim)*float(channel_rate))
    type: complex
  states: {}
- name: network_udp_sink_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '1472'
    port: '42001'
    send_eof: 'False'
    type: byte
  states: {state: disabled}
- name: qtgui_const_sink_x_0_0_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: '[5,0,1,2]'
    legend: 'False'
    name: '"output"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: channel_rate
    fc: '0'
    fftsize: '256'
    gui_hint: '[3,0,1,2]'
    showports: 'True'
    type: complex
    update_time: '0.1'
  states: {}
- name: rtlsdr_source
  id: rtlsdr_source
  parameters:
    args: ''
    bb_gain0: '0'
    corr0: ppm_corr
    freq0: frequency_mhz*1e6-freq_offset_khz*1e3
    gain0: '0'
    gain_mode0: 'True'
    if_gain0: '0'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_feedforward_agc_cc_0, '0', digital_fll_band_edge_cc_0, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', blocks_udp_sink_1_0, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', network_udp_sink_0, '0']
- [digital_constellation_decoder_cb_0_0, '0', digital_map_bb_0_0, '0']
- [digital_diff_phasor_cc_0_0, '0', digital_constellation_decoder_cb_0_0, '0']
- [digital_diff_phasor_cc_0_0, '0', qtgui_const_sink_x_0_0_0, '0']
- [digital_fll_band_edge_cc_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [digital_linear_equalizer_0, '0', digital_diff_phasor_cc_0_0, '0']
- [digital_map_bb_0_0, '0', blocks_unpack_k_bits_bb_0_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_linear_equalizer_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', mmse_resampler_xx_0, '0']
- [mmse_resampler_xx_0, '0', analog_feedforward_agc_cc_0, '0']
- [mmse_resampler_xx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [rtlsdr_source, '0', freq_xlating_fir_filter_xxx_0, '0']

metadata:
  file_format: 1
